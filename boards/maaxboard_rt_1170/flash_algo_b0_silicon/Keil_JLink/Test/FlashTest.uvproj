# Keil uVision project FlashTest.uvproj, settings and files
target STM32F103 Flash Test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: Test
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: DEBUG, FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0, CPU_MIMXRT1176DVMAA_cm7
  c include: ..\Sources;..\..\..\..\devices\MIMXRT1176;..\..\..\..\devices\MIMXRT1176\drivers;..\..\..\..\CMSIS\Include;..\..\..\..\platform\drivers\common
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  scatter file: ..\..\..\..\devices\MIMXRT1176\arm\MIMXRT1176xxxxx_cm7_ram.scf
  group Flash Algorithm Files
    ../: FlashDev.c FlashPrg.c
  group Source Files
    ../Sources/: main.c
  group Documentation
    ./: Abstract.txt
  group Sources
    ../Sources/: bl_api.c bl_api.h flexspi_nor_flash.h
    ../../../../devices/MIMXRT1176/: system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
    ../../../../devices/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.s
