# Keil uVision project MIMXRT106x_QSPI.uvproj, settings and files
target RT106x_Qspi_Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: MIMXRT106x_HON_QSPI
  AfterMake: cmd.exe /C copy "Output\%L" "MIMXRT106x_HON_QSPI_32KB_SEC.FLM"
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1062DVL6A
  c include: .\Sources;..\..\..\..\CMSIS\Include;..\..\..\..\devices\MIMXRT1062;..\..\..\..\devices\MIMXRT1062\drivers
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg_is25lp256_w25q256.c
  group Device Description
    ./: FlashDev.c
  group Sources
    ./Sources/: bl_api.c bl_api.h flexspi_nor_flash.h fsl_clock.h fsl_flexspi.h fsl_rtwdog.h fsl_wdog.h
    ../../../../devices/MIMXRT1062/: system_MIMXRT1062.c
target ARM7_ARM9 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "@L.FLX"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
