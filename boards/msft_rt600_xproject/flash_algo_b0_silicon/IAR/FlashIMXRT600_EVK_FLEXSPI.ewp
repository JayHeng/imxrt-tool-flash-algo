# IAR project FlashIMXRT600_EVK_FLEXSPI.ewp, settings and files
configuration FlashIMXRT600_EVK_FLEXSPI (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CPU_MIMXRT685EVKA
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\src\flashloader\framework2\; rom_api\; flash_config\; 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashIMXRT600_EVK_FLEXSPI.bin
  ILINK.IlinkOutputFile: $CONFIG_NAME$.out
  ILINK.IlinkIcfFile: FlashIMXRT600_RAM.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ./: FlashIMXRT600_EVK_FLEXSPI.c readme.txt
  group flash_config
    flash_config/: flash_config.h flash_config_4bit_qdr.c
  group Framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
  group rom_api
    rom_api/: bl_api.c bl_api.h
