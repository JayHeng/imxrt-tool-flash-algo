# IAR project FlashIMXRT500_MX25U.ewp, settings and files
configuration FlashIMXRT500_MX25U (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CPU_MIMXRT595FFOA
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\src\flashloader\framework2\; rom_api\; 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashIMXRT500_MX25U.bin
  ILINK.IlinkOutputFile: $CONFIG_NAME$.out
  ILINK.IlinkIcfFile: FlashIMXRT500_MX25U.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ./: FlashIMXRT500_MX25U.c readme.txt
  group Framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
  group rom_api
    rom_api/: bl_api.c bl_api.h
