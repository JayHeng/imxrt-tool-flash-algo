# Keil uVision project FlashTest.uvproj, settings and files
target STM32F103 Flash Test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: Test
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1064DVL6A
  c include: ..\CMSIS\Include;..\Sources;..\..\_Template_Flash;..\..\..\..\..\devices\MIMXRT1064;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\platform\drivers\common
  scatter file: ..\..\..\..\..\devices\MIMXRT1064\arm\MIMXRT1064xxxxx_ram.scf
  group Flash Algorithm Files
    ../: FlashDev.c FlashPrg.c
  group Source Files
    ./: FlashTest.c
  group Documentation
    ./: Abstract.txt
  group Sources
    ../Sources/: bl_api.c bl_api.h flexspi_nor_flash.h fsl_clock.h fsl_flexspi.h fsl_rtwdog.h fsl_wdog.h
    ../../../../../devices/MIMXRT1064/: system_MIMXRT1064.c system_MIMXRT1064.h
    ../../../../../devices/MIMXRT1064/arm/: startup_MIMXRT1064.s
