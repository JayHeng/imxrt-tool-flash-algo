# Keil uVision project MIMXRT117x_QSPI.uvprojx, settings and files
target RT117x_Qspi_Flash (6220000::V6.22::ARMCLANG)
  device: ARMCM7 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: MIMXRT117x_QSPI
  AfterMake: cmd.exe /C copy "Output\%L" "MIMXRT117x_QuadSPI_4KB_SEC.FLM"
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  c flags: Optim=3 uC99=1 uGnu=1 v6Lang=3 v6LangP=5
  c define: CPU_MIMXRT1176DVMAA_cm7,USE_ROM_API
  c include: ..\Keil_JLink;.\Sources;.\rom;.\cm7;..\..\..\..\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Sources
    ./Sources/: fsl_clock.c fsl_anatop.c fsl_anatop_ai.c fsl_common.c flexspi_nor_flash_ops.c fsl_flexspi.c
  group ROMAPI
    ./rom/: fsl_romapi.c fsl_romapi.h
target ARM7_ARM9 (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.25.03.00
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x20000000,0x040000) IROM(0x00200000,0x040000) XRAM(0x1ffe0000,0x020000) XRAM2(0x00000000,0x040000) XRAM3(0x20240000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "@L.FLX"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x200000 size 0x40000
  memory RVCT6: ROM 0x1ffe0000 size 0x20000
  memory RVCT7: ROM 0x0 size 0x40000
  memory RVCT8: ROM 0x20240000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RT117x_Qspi_Flash_M4 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM7 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: MIMXRT117x_QSPI_Alias
  AfterMake: cmd.exe /C copy "Output\%L" "MIMXRT117x_QuadSPI_4KB_SEC_Alias.FLM"
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  c flags: Optim=3 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1176DVMAA_cm4, ALIAS_PROGRAM, FSL_SDK_DISABLE_DRIVER_CLOCK_CONTROL = 1,USE_ROM_API
  c include: .\Sources;..\..\..\CMSIS\Include;..\..\..\devices\MIMXRT1176\drivers\romapi;..\..\..\devices\MIMXRT1176\drivers;..\..\..\devices\MIMXRT1176;..\..\..\platform\drivers\common;..\..\..\devices\MIMXRT1176\drivers;..\;..\..\..\platform\drivers\igpio;..\..\..\platform\drivers\flexspi;..\..\src\driver_examples\flexspi\nor\polling_transfer;.\cm4
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
