# Keil uVision project MIMXRT117x_QSPI.uvproj, settings and files
target RT117x_Qspi_Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: MIMXRT117x_FLEXSPI
  AfterMake: cmd.exe /C copy "Output\%L" "MIMXRT117x_B0_QuadSPI_4KB_SEC.FLM"
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1176DVMAA_cm7
  c include: ..\..\..\..\CMSIS\Include;..\..\..\..\devices\MIMXRT1176\drivers;..\..\..\..\devices\MIMXRT1176\drivers\romapi;..\..\..\..\devices\MIMXRT1176;..\
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg_is25wp128.c
  group Device Description
    ./: FlashDev_is25wp128.c
  group Sources
    ../../../../devices/MIMXRT1176/: system_MIMXRT1176_cm7.c
    ../../../../devices/MIMXRT1176/drivers/: fsl_anatop.c fsl_anatop_ai.c fsl_clock.c fsl_common.c
    ../../../../devices/MIMXRT1176/drivers/romapi/: fsl_romapi.c fsl_romapi.h
target ARM7_ARM9 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "@L.FLX"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
