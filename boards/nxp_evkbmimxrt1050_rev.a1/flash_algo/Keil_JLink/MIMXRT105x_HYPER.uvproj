# Keil uVision project MIMXRT105x_HYPER.uvproj, settings and files
target RT1050_Hyper_Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: MIMXRT105x_HYPER
  AfterMake: cmd.exe /C copy "Output\%L" "MIMXRT105x_HYPER_256KB_SEC.FLM"
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1052DVL6B
  c include: .\middleware;..\..\..\..\CMSIS\Include;..\..\..\..\devices\MIMXRT1052;..\..\..\..\devices\MIMXRT1052\drivers
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg_s26ks512s.c
  group Device Description
    ./: FlashDev_s26ks512s.c
  group Bsp
    ./bsp/src/: clock_config_MIMXRT1051.c hardware_init_MIMXRT1051.c
    ../../../../devices/MIMXRT1052/drivers/: fsl_clock.c
  group Flash_driver_lib
    ./middleware/flexspi_nor/: flexspi_nor_flash.c
    ./middleware/flexspi/: fsl_flexspi.c
  group Startup
    ../../../../devices/MIMXRT1052/: system_MIMXRT1052.c
target ARM7_ARM9 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "@L.FLX"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
