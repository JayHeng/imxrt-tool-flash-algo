# Keil uVision project FlashTest.uvproj, settings and files
target STM32F103 Flash Test (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: Test
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1052DVL6B
  c include: ..\middleware;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\devices\MIMXRT1052;..\..\..\..\..\devices\MIMXRT1052\drivers;..\..\..\..\..\platform\drivers\common
  scatter file: ..\..\..\..\..\devices\MIMXRT1052\arm\MIMXRT1052xxxxx_ram.scf
  group Startup Code
    ../../../../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.s
    ../../../../../devices/MIMXRT1052/: system_MIMXRT1052.c
  group Flash Algorithm Files
    ../: FlashDev.c FlashPrg.c
  group Source Files
    ./: FlashTest.c
  group Documentation
    ./: Abstract.txt
  group MIMXRT1050
    ../bsp/src/: clock_config_MIMXRT1051.c hardware_init_MIMXRT1051.c
  group Drivers
    ../middleware/flexspi_nor/: flexspi_nor_flash.c
    ../middleware/flexspi/: fsl_flexspi.c
    ../../../../../devices/MIMXRT1052/drivers/: fsl_clock.c
