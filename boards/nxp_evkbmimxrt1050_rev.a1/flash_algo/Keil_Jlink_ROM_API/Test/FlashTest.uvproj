# Keil uVision project FlashTest.uvproj, settings and files
target STM32F103 Flash Test (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: Test
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1062DVL6A
  c include: ..\Sources;..\..\..\..\devices\MIMXRT1062;..\..\..\..\CMSIS\Include;..\..\..\..\platform\drivers\common
  scatter file: ..\..\..\..\devices\MIMXRT1062\arm\MIMXRT1062xxxxx_ram.scf
  group Flash Algorithm Files
    ../: FlashDev.c FlashPrg.c
  group Source Files
    ./: FlashTest.c
  group Documentation
    ./: Abstract.txt
  group Sources
    ../Sources/: bl_api.c bl_api.h flexspi_nor_flash.h fsl_clock.h fsl_flexspi.h fsl_rtwdog.h fsl_wdog.h
    ../../../../devices/MIMXRT1062/: system_MIMXRT1062.c system_MIMXRT1062.h
    ../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.s
