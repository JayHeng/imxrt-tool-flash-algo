# Keil uVision project MIMXRT117x_QSPI.uvproj, settings and files
target RT117x_Qspi_Flash (6220000::V6.22::ARMCLANG)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: MIMXRT117x_QSPI
  AfterMake: cmd.exe /C copy "Output\%L" "MIMXRT117x_QuadSPI_64KB_SEC.FLM"
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  c flags: Optim=3 uC99=1 uGnu=1 v6Lang=3 v6LangP=5
  c define: CPU_MIMXRT1176DVMAA_cm7
  c include: .\Sources;.\cm7;..\cmsis_pack_flash_algo
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Sources
    ./Sources/: fsl_common.c fsl_common_arm.c fsl_anatop_ai.c fsl_clock.c fsl_pmu.c
  group SDK Drivers
    ./Sources/: flexspi_nor_flash_ops.c fsl_flexspi.c
  group ROMAPI
    ./Sources/: fsl_romapi.c fsl_romapi.h
target ARM7_ARM9 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "@L.FLX"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RT117x_Qspi_Flash_M4 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: MIMXRT117x_QSPI_Alias
  AfterMake: cmd.exe /C copy "Output\%L" "MIMXRT117x_QuadSPI_4KB_SEC_Alias.FLM"
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  c flags: Optim=3 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1176DVMAA_cm4, ALIAS_PROGRAM, FSL_SDK_DISABLE_DRIVER_CLOCK_CONTROL = 1,USE_ROM_API
  c include: .\Sources;..\..\..\CMSIS\Include;..\..\..\devices\MIMXRT1176\drivers\romapi;..\..\..\devices\MIMXRT1176\drivers;..\..\..\devices\MIMXRT1176;..\..\..\platform\drivers\common;..\..\..\devices\MIMXRT1176\drivers;..\;..\..\..\platform\drivers\igpio;..\..\..\platform\drivers\flexspi;..\..\src\driver_examples\flexspi\nor\polling_transfer;.\cm4
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
