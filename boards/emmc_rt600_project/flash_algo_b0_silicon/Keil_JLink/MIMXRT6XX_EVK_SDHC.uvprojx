# Keil uVision project MIMXRT6XX_EVK_SDHC.uvprojx, settings and files
target MIMXRT6XX_EVK_SDHC (6220000::V6.22::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: MIMXRT6XX_EVK_SDHC
  AfterMake: cmd.exe /C copy "!L" "@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1 wLevel=2
  c define: BOOTLOADER_HOST, CPU_MIMXRT685SFVKB_cm33, NDEBUG, CPU_IS_ARM_CORTEX_M33=1, MCUXPRESSO_SDK, SDK_OS_BAREMETAL
  c misc: -Wno-pedantic -Wno-padded -Wno-cast-align  -Wno-missing-variable-declarations -Wno-unused-parameter  -Wno-missing-prototypes  -Wno-covered-switch-default -Wno-missing-braces
  c include: .;.\emmc
  asm include: .
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg_mx52lm04a11.c
  group Device Description
    ./: FlashDev_mx52lm04a11.c
  group emmc
    ./emmc/: bl_main.c bl_usdhc.c clock_config_MIMXRT685S.c fsl_clock.c fsl_gpio.c fsl_mmc.c fsl_reset.c fsl_sdmmc_common.c fsl_sdmmc_host.c hardware_init_MIMXRT685S.c memory.c microseconds_sysclk.c mmc_memory.c sdmmc_config_MIMXRT685S.c fsl_common_arm.c
software components: CMSIS:CORE 5.0.1
