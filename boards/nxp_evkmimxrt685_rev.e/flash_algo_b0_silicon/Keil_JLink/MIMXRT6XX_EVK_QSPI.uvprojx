# Keil uVision project MIMXRT6XX_EVK_QSPI.uvprojx, settings and files
target MIMXRT6XX_EVK_QSPI (6120000::V6.12::.\ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: MIMXRT6XX_B0_EVK_FLEXSPI
  AfterMake: cmd.exe /C copy "!L" "@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1 wLevel=2
  c define: BOOTLOADER_HOST
  c misc: -Wno-pedantic -Wno-padded -Wno-cast-align  -Wno-missing-variable-declarations -Wno-unused-parameter  -Wno-missing-prototypes  -Wno-covered-switch-default -Wno-missing-braces
  c include: .
  asm include: .
  library: MicroLIB
  memory RVCT4: ROM 0xc000 size 0x74000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x100000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --entry 0xc001
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group rom_api
    ./: bl_api.c
software components: CMSIS:CORE 5.0.1
