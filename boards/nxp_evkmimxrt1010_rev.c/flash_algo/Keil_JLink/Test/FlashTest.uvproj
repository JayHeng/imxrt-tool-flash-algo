# Keil uVision project FlashTest.uvproj, settings and files
target STM32F103 Flash Test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: Test
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1011DAE5A
  c include: ..\middleware;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\devices\MIMXRT1011;..\..\..\..\..\devices\MIMXRT1011\drivers;..\..\..\..\..\platform\drivers\common
  scatter file: ..\..\..\..\..\devices\MIMXRT1011\arm\MIMXRT1011xxxxx_ram.scf
  group Startup Code
    ../../../../../devices/MIMXRT1011/: system_MIMXRT1011.c
    ../../../../../devices/MIMXRT1011/arm/: startup_MIMXRT1011.s
  group Flash Algorithm Files
    ../: FlashDev.c FlashPrg.c
  group Source Files
    ../application/: main.c
  group Documentation
    ./: Abstract.txt
  group MIMXRT1011
    ../bsp/src/: clock_config_MIMXRT1011.c hardware_init_MIMXRT1011.c
  group Drivers
    ../middleware/flexspi_nor/: flexspi_nor_flash.c
    ../middleware/flexspi/: fsl_flexspi.c
    ../../../../../devices/MIMXRT1011/drivers/: fsl_clock.c
