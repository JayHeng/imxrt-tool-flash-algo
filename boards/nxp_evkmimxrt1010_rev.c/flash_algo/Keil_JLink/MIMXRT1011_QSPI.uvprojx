# Keil uVision project MIMXRT1011_QSPI.uvprojx, settings and files
target RT1011 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.1.0.0
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x00000000,0x8000) XRAM(0x20200000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: MIMXRT1011_QSPI
  AfterMake: cmd.exe /C copy "Output\%L" "MIMXRT1011_QuadSPI_4KB_SEC.FLM"
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1011DAE5A
  c include: .\middleware;..\..\..\..\CMSIS\Include;..\..\..\..\devices\MIMXRT1011;..\..\..\..\devices\MIMXRT1011\drivers;..\..\..\..\platform\drivers\common
  memory RVCT6: RAM 0x20200000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x0 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg_at25sf128a.c
  group Device Description
    ./: FlashDev_at25sf128a.c
  group Bsp
    ./bsp/src/: clock_config_MIMXRT1011.c hardware_init_MIMXRT1011.c
    ../../../../devices/MIMXRT1011/drivers/: fsl_clock.c
  group Flash_driver_lib
    ./middleware/flexspi_nor/: flexspi_nor_flash.c
    ./middleware/flexspi/: fsl_flexspi.c
  group Startup
    ../../../../devices/MIMXRT1011/: system_MIMXRT1011.c
software components: CMSIS:CORE 5.4.0
