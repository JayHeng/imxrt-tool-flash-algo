# Keil uVision project MIMXRT1180_FLEXSPI.uvprojx, settings and files
target MIMXRT1180_EVBA_FLEXSPI (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189XVM8B:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.19.0.0
  cpu: IRAM(0x20484000,0x07c000) IRAM2(0x20500000,0x040000) IROM(0x00000000,0x028000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: MIMXRT1180_EVBA_FLEXSPI
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1 wLevel=2
  c define: RT1180_EVB_A,CPU_MIMXRT1189CVM8B_cm33
  c misc: -Wno-pedantic -Wno-padded -Wno-cast-align  -Wno-missing-variable-declarations -Wno-unused-parameter  -Wno-missing-prototypes  -Wno-covered-switch-default -Wno-missing-braces
  c include: .;rom_api/
  asm include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group rom_api
    ./rom_api/: fsl_romapi.c
target MIMXRT1180_FPGA_FLEXSPI (6160000::V6.16::ARMCLANG)
  device: MIMXRT1189CVM8B:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.19.0.0
  cpu: as above
  output: MIMXRT1180_FLEXSPI
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1 wLevel=2
  c misc: as above
  asm include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MIMXRT1180_EVK_FSPI1_QSPI_CM33 (6240000::V6.24::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: MIMXRT1180_EVK_FSPI1_QSPI_CM33
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1 wLevel=2
  c define: RT1180_EVK_FSPI1_QSPI,CPU_MIMXRT1189CVM8B_cm33
  c misc: as above
  c include: .;rom_api/
  asm include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305 --debug --symdefs=symbols.sym
target MIMXRT1180_EVK_FSPI1_QSPI_CM33_SEC (6240000::V6.24::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: MIMXRT1180_EVK_FSPI1_QSPI_CM33_3800
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1 wLevel=2
  c define: RT1180_EVK_FSPI1_QSPI,CPU_MIMXRT1189CVM8B_cm33,SECURE_ADDR
  c misc: as above
  c include: .;rom_api/
  asm include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305 --debug --symdefs=symbols.sym
target MIMXRT1180_EVK_FSPI1_QSPI_CM33_ALIAS (6240000::V6.24::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: MIMXRT1180_EVK_FSPI1_QSPI_CM33_0200
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1 wLevel=2
  c define: RT1180_EVK_FSPI1_QSPI,CPU_MIMXRT1189CVM8B_cm33,ALIAS_ADDR
  c misc: as above
  c include: .;rom_api/
  asm include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305 --debug --symdefs=symbols.sym
target MIMXRT1180_EVK_FSPI1_QSPI_CM33_ALIAS_SEC (6240000::V6.24::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: MIMXRT1180_EVK_FSPI1_QSPI_CM33_1200
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1 wLevel=2
  c define: RT1180_EVK_FSPI1_QSPI,CPU_MIMXRT1189CVM8B_cm33,ALIAS_ADDR,SECURE_ADDR
  c misc: as above
  c include: .;rom_api/
  asm include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305 --debug --symdefs=symbols.sym
target MIMXRT1180_EVK_FSPI1_QSPI_CM7 (6240000::V6.24::ARMCLANG)
  device: ARMCM7 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: MIMXRT1180_EVK_FSPI1_QSPI_CM7
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1 wLevel=2
  c define: RT1180_EVK_FSPI1_QSPI,CPU_MIMXRT1189CVM8B_cm7
  c misc: as above
  c include: .;rom_api/
  asm include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305 --debug --symdefs=symbols.sym
target MIMXRT1180_FRDM_FLEXSPI_CM33 (6240000::V6.24::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: MIMXRT1180_FRDM_FSPI2_QSPI_CM33
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1 wLevel=2
  c define: RT1180_FRDM,CPU_MIMXRT1189CVM8B_cm33
  c misc: as above
  c include: .;rom_api/
  asm include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305 --debug --symdefs=symbols.sym
target MIMXRT1180_FRDM_FLEXSPI_CM33_SEC (6240000::V6.24::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: MIMXRT1180_FRDM_FSPI2_QSPI_CM33_1400
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1 wLevel=2
  c define: RT1180_FRDM,CPU_MIMXRT1189CVM8B_cm33,SECURE_ADDR
  c misc: as above
  c include: .;rom_api/
  asm include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305 --debug --symdefs=symbols.sym
target MIMXRT1180_FRDM_FLEXSPI_CM33_ALIAS (6240000::V6.24::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: MIMXRT1180_FRDM_FSPI2_QSPI_CM33_2200
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1 wLevel=2
  c define: RT1180_FRDM,CPU_MIMXRT1189CVM8B_cm33,ALIAS_ADDR
  c misc: as above
  c include: .;rom_api/
  asm include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305 --debug --symdefs=symbols.sym
target MIMXRT1180_FRDM_FLEXSPI_CM33_ALIAS_SEC (6240000::V6.24::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: MIMXRT1180_FRDM_FSPI2_QSPI_CM33_3200
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1 wLevel=2
  c define: RT1180_FRDM,CPU_MIMXRT1189CVM8B_cm33,ALIAS_ADDR,SECURE_ADDR
  c misc: as above
  c include: .;rom_api/
  asm include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305 --debug --symdefs=symbols.sym
target MIMXRT1180_FRDM_FLEXSPI_CM7 (6240000::V6.24::ARMCLANG)
  device: ARMCM7 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ESEL ELITTLE
  output: MIMXRT1180_FRDM_FSPI2_QSPI_CM7
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1 wLevel=2
  c define: RT1180_FRDM,CPU_MIMXRT1189CVM8B_cm7
  c misc: as above
  c include: .;rom_api/
  asm include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305 --debug --symdefs=symbols.sym
software components: CMSIS:CORE 6.2.0
