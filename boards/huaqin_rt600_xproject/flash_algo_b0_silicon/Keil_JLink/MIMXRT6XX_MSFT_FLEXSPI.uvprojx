# Keil uVision project MIMXRT6XX_MSFT_FLEXSPI.uvprojx, settings and files
target MIMXRT6XX_MSFT_FLEXSPI (6140000::V6.14::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: MIMXRT6XX_B0_MSFT_FLEXSPI
  AfterMake: cmd.exe /C copy "!L" "@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=1 wLevel=2
  c define: BOOTLOADER_HOST
  c misc: -Wno-pedantic -Wno-padded -Wno-cast-align  -Wno-missing-variable-declarations -Wno-unused-parameter  -Wno-missing-prototypes  -Wno-covered-switch-default -Wno-missing-braces
  c include: .;flash_config/
  asm include: .
  memory RVCT4: ROM 0x0 size 0x74000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./flash_config/: flash_config_4bit_qdr.c
    ./: FlashPrg_gd25lq64e_qe.c
  group Device Description
    ./: FlashDev_gd25lq64e.c
  group rom_api
    ./: bl_api.c
software components: CMSIS:CORE 5.0.1
