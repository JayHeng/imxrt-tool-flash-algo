# Keil uVision project FlashTest.uvproj, settings and files
target STM32F103 Flash Test (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: Test
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1021DAG5A
  c include: ..\middleware;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\devices\MIMXRT1021;..\..\..\..\..\devices\MIMXRT1021\drivers;..\..\..\..\..\platform\drivers\common
  scatter file: ..\..\..\..\..\devices\MIMXRT1021\arm\MIMXRT1021xxxxx_ram.scf
  group Startup Code
    ../../../../../devices/MIMXRT1021/: system_MIMXRT1021.c
    ../../../../../devices/MIMXRT1021/arm/: startup_MIMXRT1021.s
  group Flash Algorithm Files
    ../: FlashDev.c FlashPrg.c
  group Source Files
    ./: FlashTest.c
  group Documentation
    ./: Abstract.txt
  group MIMXRT1021
    ../bsp/src/: clock_config_MIMXRT1021.c hardware_init_MIMXRT1021.c
  group Drivers
    ../middleware/flexspi_nor/: flexspi_nor_flash.c
    ../middleware/flexspi/: fsl_flexspi.c
    ../../../../../devices/MIMXRT1021/drivers/: fsl_clock.c
