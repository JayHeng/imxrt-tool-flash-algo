# Keil uVision project MIMXRT1021_QSPI.uvprojx, settings and files
target RT1020 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.12.3.0
  cpu: IRAM(0x20000000,0x010000) IRAM2(0x00000000,0x010000) IROM(0x00200000,0x018000) XRAM(0x20200000,0x020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: MIMXRT1021_QSPI
  AfterMake: cmd.exe /C copy "Output\%L" "MIMXRT1021_QuadSPI_4KB_SEC.FLM"
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1021DAG5A
  c include: .\middleware;..\..\..\..\CMSIS\Include;..\..\..\..\devices\MIMXRT1021;..\..\..\..\devices\MIMXRT1021\drivers;..\..\..\..\platform\drivers\common
  memory RVCT4: ROM 0x200000 size 0x18000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg_is25lp064a.c
  group Device Description
    ./: FlashDev_is25lp064a.c
  group Bsp
    ./bsp/src/: clock_config_MIMXRT1021.c hardware_init_MIMXRT1021.c
    ../../../../devices/MIMXRT1021/drivers/: fsl_clock.c
  group Flash_driver_lib
    ./middleware/flexspi_nor/: flexspi_nor_flash.c
    ./middleware/flexspi/: fsl_flexspi.c
  group Startup
    ../../../../devices/MIMXRT1021/: system_MIMXRT1021.c
target ARM7_ARM9 (ARM-ADS)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.12.3.0
  cpu: as above
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "@L.FLX"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x200000 size 0x18000
  memory RVCT6: ROM 0x20200000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
