# Keil uVision project MIMXRT1024_QSPI.uvprojx, settings and files
target RT1024 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1024DAG5A NXP
  pack: NXP.MIMXRT1024_DFP.12.0.0
  cpu: IRAM(0x20000000,0x010000) IRAM2(0x00000000,0x010000) IROM(0x60000000,0x400000) XRAM(0x20200000,0x020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: MIMXRT1024_QSPI
  AfterMake: cmd.exe /C copy "Output\%L" "MIMXRT1024_QuadSPI_4KB_SEC.FLM"
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1024DAG5A
  c include: .\middleware;..\..\..\..\CMSIS\Include;..\..\..\..\devices\MIMXRT1024;..\..\..\..\devices\MIMXRT1024\drivers;..\..\..\..\platform\drivers\common
  memory RVCT4: ROM 0x60000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Sources
    ./Sources/: fsl_romapi.c fsl_romapi.h
