<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FlashIMXRT1060_IS25W.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>FlashIMXRT1060_IS25W</project>
        <configuration>FlashIMXRT1060_IS25W</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


