# IAR project FlashIMXRT1060_IS25W.ewp, settings and files
configuration FlashIMXRT1060_IS25W (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx5A NXP MIMXRT1062xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MIMXRT1062DVL6A
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\src\flashloader\framework2\; rom_api\; ; ..\..\..\..\CMSIS\Include\; ..\..\..\..\devices\MIMXRT1062\; ..\..\..\..\devices\MIMXRT1062\drivers\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashIMXRT1060_IS25W.bin
  ILINK.IlinkOutputFile: $CONFIG_NAME$.out
  ILINK.IlinkIcfFile: FlashIMXRT1060_IS25W.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ./: FlashIMXRT1060_IS25W.c readme.txt
  group Framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
  group rom_api
    rom_api/: bl_api.c bl_api.h
